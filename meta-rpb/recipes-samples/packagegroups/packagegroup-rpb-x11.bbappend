RDEPENDS_packagegroup-rpb-x11_append = " kmscube"
