RDEPENDS_packagegroup-rpb-weston_append = " kmscube"
