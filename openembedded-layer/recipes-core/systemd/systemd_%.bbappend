FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-50-udev-default.rules.in-set-correct-group-for-media.patch"
